# Keil uVision project temper measure.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temper_measure +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 12864.c 12864.h delay.c delay.h main.c key.c key.h dht11.h dht11.c showtemperature.c showtemperature.h ired.c ired.h uart.c wifi_control.c wifi_control.h uart.h IIc.c IIc.h
